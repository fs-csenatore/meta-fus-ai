PACKAGECONFIG:append = " gtk"

PACKAGECONFIG[gtk]        = "-Dgtk3=enabled,-Dgtk3=disabled,gtk+3,gtk+3"
