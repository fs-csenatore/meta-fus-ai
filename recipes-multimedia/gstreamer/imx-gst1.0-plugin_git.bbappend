CFLAGS:append = " -DENABLE_ALL_PXP_FORMATS=1"
